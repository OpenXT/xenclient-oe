# Disables 'src_distribute_local.bbclass' from OpenEmbedded.
