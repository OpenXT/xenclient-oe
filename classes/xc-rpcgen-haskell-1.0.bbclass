RPCGEN_VERSION = "1.0"
require xc-rpcgen-haskell.inc
