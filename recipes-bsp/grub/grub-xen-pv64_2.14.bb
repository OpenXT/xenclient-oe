require grub-xen.inc
GRUBPLATFORM = "xen"
GRUB_TARGET = "x86_64"
GRUBEXT = "${GRUBPLATFORM}-pv64"
