require grub-xen.inc
GRUBPLATFORM = "xen_pvh"
GRUB_TARGET = "i386"
GRUBEXT = "xen-pvh"
