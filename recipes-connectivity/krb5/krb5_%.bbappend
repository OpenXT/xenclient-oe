FILESEXTRAPATHS_prepend := "${THISDIR}/krb5:"

SRC_URI += "file://CVE-2017-11462.patch;striplevel=2"
