SRC_URI = "${OPENXT_MIRROR}/base-passwd_${PV}.tar.gz \
           file://nobash.patch \
           file://root-home.patch"
