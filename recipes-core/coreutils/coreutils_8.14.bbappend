PRINC = "1"

DEPENDS += "libselinux"
EXTRA_OECONF += "--with-selinux"
