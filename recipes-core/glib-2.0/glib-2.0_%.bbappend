EXTRA_OECONF:append = " \
    --disable-Bsymbolic \
"
