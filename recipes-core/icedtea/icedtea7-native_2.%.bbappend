CXX_append += " -Wno-error=stringop-overflow -Wno-error=deprecated-declarations -Wno-error=return-type"
