PR .= ".1"

SRC_URI="https://github.com/clarkware/jdepend/archive/${PV}.zip"

SRC_URI[md5sum] = "9b91efe1d770e023893f89f4dde8434e"
SRC_URI[sha256sum] = "536b5082d64e4f4dddd514ce30178f36c7a31b34d969275f278f72e522e7f7c9"
