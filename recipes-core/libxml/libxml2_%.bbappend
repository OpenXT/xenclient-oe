FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://fix-CVE-2017-8872.patch"
