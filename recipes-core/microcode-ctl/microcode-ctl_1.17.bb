SRC_URI[md5sum] = "98a7f06acef8459c8ef2a1b0fb86a99e"
SRC_URI[sha256sum] = "41ef081c3a2649ca012714a3e2034d748612b1a8f007aa275f395f81cb230bb7"
require recipes-core/microcode-ctl/microcode-ctl.inc
