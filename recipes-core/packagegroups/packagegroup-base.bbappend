PR .= ".1"

RDEPENDS:packagegroup-base-keyboard = "\
    kbd \
    xenclient-console-keymaps"
