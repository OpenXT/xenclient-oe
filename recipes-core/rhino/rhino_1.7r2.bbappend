SRC_URI = "\
	https://ftp.mozilla.org/pub/mozilla.org/js/rhino1_7R2.zip \
	file://rhino \
	file://rhino-jsc \
	"
