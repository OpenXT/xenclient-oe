PRINC = "1"

RDEPENDS_task-base-keyboard = "\
    console-tools \
    xenclient-console-keymaps"
