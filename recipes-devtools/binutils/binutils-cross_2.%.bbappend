# enable i386pep which is required for the Xen efi build

EXTRA_OECONF += "--enable-targets=x86_64-pep"
