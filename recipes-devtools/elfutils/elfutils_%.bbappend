FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://0002-libelf-Return-error-if-elf_compress_gnu-is-used-on-S.patch"
