FILESEXTRAPATHS_prepend := "${THISDIR}/gcc-5.2:"
SRC_URI += " \
    file://CVE-2016-6131.patch \
"
