SRC_URI[md5sum] = "3a687f7cdf6878497ac23f630fafcd46"
SRC_URI[sha256sum] = "a8c54f7068fe8295f216e44e33d2d1e9f9cd12518eb0abe3a36802080306bb93"

require recipes-devtools/ghc-libs/ghc-lib-common.inc

DESCRIPTION = "unit testing"
LICENSE = "MIT"
LIC_FILES_CHKSUM="file://LICENSE;md5=cb61534369f1bbb7cbe62e014d3d5717"
GHC_PN = "hxt-charproperties"
