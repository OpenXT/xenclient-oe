BBCLASSEXTEND = "native"
SRC_URI[md5sum] = "852dc0b79cc2bcb39136287d3dd385e5"
SRC_URI[sha256sum] = "e5aa0c1ec97ad98c389e78f59aca25ab028980a7068a3e585e39564662739591"
require recipes-devtools/ghc-libs/ghc-lib-common.inc

DESCRIPTION = "Monad Transformers for ghc"
LICENSE = "GHCL"
LIC_FILES_CHKSUM = "file://LICENSE;md5=315290737f6293f698ed37113aa1226d"
GHC_PN = "transformers"
