# m4-ptest pulls locale-base-fr-fr.iso-8859-1 without a declared dep.
INSANE_SKIP:${PN}-ptest += "build-deps"
