PRINC = "1"
RDEPENDS_${PN} += "glibc-gconv-ibm850"
