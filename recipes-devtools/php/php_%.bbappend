FILESEXTRAPATHS_prepend := "${THISDIR}/php:"

SRC_URI += "file://CVE-2017-9120.patch"
