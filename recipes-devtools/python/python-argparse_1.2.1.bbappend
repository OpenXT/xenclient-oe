PRINC = "1"

RDEPENDS_${PN} += "python-textutils"
