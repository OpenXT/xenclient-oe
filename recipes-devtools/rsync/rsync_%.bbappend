PACKAGECONFIG:append += "attr"
