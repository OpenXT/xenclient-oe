PR .= "r1"

EXTRA_OECONF += "--enable-xattr-support"
