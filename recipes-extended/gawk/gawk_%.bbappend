INSANE_SKIP:${PN}-ptest += "build-deps"
