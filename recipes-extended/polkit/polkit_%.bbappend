USERADD_PARAM:${PN}:prepend = "-s /bin/false "
