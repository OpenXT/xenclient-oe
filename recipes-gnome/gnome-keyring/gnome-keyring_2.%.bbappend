PNBLACKLIST[gnome-keyring] = ""
