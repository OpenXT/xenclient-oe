PR .= ".1"

EXTRA_OECONF += "--enable-wide-chars"

B = "${S}"
