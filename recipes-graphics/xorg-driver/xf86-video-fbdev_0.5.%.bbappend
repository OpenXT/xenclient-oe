FILESEXTRAPATHS_prepend := "${THISDIR}/patches:"

SRC_URI += " \
    file://fbdev-randr1.2.patch \
"
