PV="1.19.5"

SRC_URI_remove = "file://CVE-2017-10971-1.patch"
SRC_URI_remove = "file://CVE-2017-10971-2.patch"
SRC_URI_remove = "file://CVE-2017-10971-3.patch"

SRC_URI[md5sum] = "4ac6feeae6790436ce9de879ca9a3bf8"
SRC_URI[sha256sum] = "18fffa8eb93d06d2800d06321fc0df4d357684d8d714315a66d8dfa7df251447"
