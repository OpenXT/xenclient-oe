SRC_URI[md5sum] = "2d8364cd2043ef5c71291a4ca8b8084e"
SRC_URI[sha256sum] = "593a766e9e901c2511c64ff8da85b13835a276f4298ce2c6dbd36e1c5fee59ce"

LIC_FILES_CHKSUM = "file://../COPYING;md5=8afcf1afe46c0b520e2e31427acbd718"

require intel-e1000e.inc

