require recipes-kernel/intel/intel-microcode.inc

SRC_URI = "${OPENXT_MIRROR}/microcode-${PV}.tgz " 
SRC_URI[md5sum] = "40008cd2a18a96bf04d3290e8faad812"
SRC_URI[sha256sum] = "7b6ba0db102581674c29a2e2b859ba51e5cfb11e6cbef9056e4ac6cde2116386"
