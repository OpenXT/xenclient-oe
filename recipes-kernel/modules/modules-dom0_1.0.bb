require modules.inc

DESCRIPTION += "Dom0 specific package."

PR = "${INC_PR}.1"
