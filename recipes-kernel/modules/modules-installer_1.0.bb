require modules.inc

DESCRIPTION += "Installer specific package."

PR = "${INC_PR}.1"
