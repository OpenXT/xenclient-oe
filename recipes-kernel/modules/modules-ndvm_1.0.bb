require modules.inc

DESCRIPTION += "NDVM specific package."

PR = "${INC_PR}.1"
