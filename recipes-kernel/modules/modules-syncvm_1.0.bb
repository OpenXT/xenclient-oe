require modules.inc

DESCRIPTION += "SyncVM specific package."

PR = "${INC_PR}.1"
