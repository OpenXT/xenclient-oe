require modules.inc

DESCRIPTION += "UIVM specific package."

PR = "${INC_PR}.1"
