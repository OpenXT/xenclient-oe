inherit module-signing

KERNEL_MODULE_AUTOLOAD:append:xenclient-uivm += "openxtfb"
