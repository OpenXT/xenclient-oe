inherit module-signing
