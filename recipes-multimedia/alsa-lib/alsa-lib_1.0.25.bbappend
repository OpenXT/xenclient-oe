FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
SRC_URI += " \
    file://move-asound_conf.patch \
    "
