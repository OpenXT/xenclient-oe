require dm-wrapper.inc

SRCREV = "${AUTOREV}"

ASNEEDED = ""