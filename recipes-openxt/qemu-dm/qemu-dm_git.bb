require recipes-openxt/qemu-dm/qemu-dm.inc

SRCREV_source = "${AUTOREV}"
SRCREV_patchqueue = "${AUTOREV}"
