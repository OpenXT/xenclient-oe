require xenclient-dom0-tweaks.inc

PR="${INC_PR}.0"
