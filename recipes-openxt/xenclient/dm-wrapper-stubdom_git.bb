require dm-wrapper.inc

SRCREV = "${AUTOREV}"

EXTRA_OECONF += "--disable-syslog"
