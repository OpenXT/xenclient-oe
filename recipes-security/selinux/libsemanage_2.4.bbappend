PACKAGE_BEFORE_PN = "${PN}-utils"

FILES_${PN}-utils = "/usr/libexec/selinux/*"

RDEPENDS_${PN}-utils = "python"

