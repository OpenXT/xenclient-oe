SRC_URI =+ "https://raw.githubusercontent.com/wiki/TresysTechnology/setools3/files/dists/${PN}-${PV}/${PN}-${PV}.tar.bz2"
