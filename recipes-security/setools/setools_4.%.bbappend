RDEPENDS_${PN} += " \
    python-2to3 \
    python-argparse \
"
