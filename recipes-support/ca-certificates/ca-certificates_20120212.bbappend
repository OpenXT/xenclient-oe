PRINC = "1"
SRC_URI = "http://snapshot.debian.org/archive/debian/20120229T213309Z/pool/main/c/ca-certificates/ca-certificates_${PV}.tar.gz \
           file://0001-update-ca-certificates-remove-c-rehash.patch"
