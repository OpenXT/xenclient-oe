PR .= ".1"

PACKAGECONFIG_class-native = "gnutls zlib"
