FILESEXTRAPATHS_prepend := "${THISDIR}/icu:"

SRC_URI += "file://CVE-2017-14952.patch"
