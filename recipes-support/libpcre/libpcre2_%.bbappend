FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://libpcre2-CVE-2017-8786.patch"
