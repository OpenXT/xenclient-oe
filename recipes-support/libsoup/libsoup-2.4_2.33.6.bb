require libsoup.inc

LIC_FILES_CHKSUM = "file://COPYING;md5=55ca817ccb7d5b5b66355690e9abc605"

# Need too new glib-2.0
#DEFAULT_PREFERENCE = "-1"

SRC_URI[libsoup.md5sum] = "3a7219057d289dd7dcdd67681d27eebe"
SRC_URI[libsoup.sha256sum] = "988f7897fe125a77a5946b2fd6d47d7374fd94a1406e810482cfff6a52a6a923"

