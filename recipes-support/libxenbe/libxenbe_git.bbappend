# CMake 4 dropped compatibility with cmake_minimum_required() < 3.5.
EXTRA_OECMAKE += "-DCMAKE_POLICY_VERSION_MINIMUM=3.5"
