FILESEXTRAPATHS_prepend := "${THISDIR}/libxslt:"

SRC_URI += "file://0001-Fix-security-framework-bypass.patch"
