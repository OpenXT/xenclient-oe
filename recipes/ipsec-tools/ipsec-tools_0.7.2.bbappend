LIC_FILES_CHKSUM = "file://Makefile.in;endline=14;md5=764d2275f40f1a67205558dd2af91708"
