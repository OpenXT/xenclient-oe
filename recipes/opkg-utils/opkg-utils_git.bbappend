#TODO: kill that recipe after upgrading to the new OE that provides at list that revision of opkg-utils
PRINC = "1"
SRCREV = "757a1664a440c60e8126443bf984e4bdf374c327"
SRC_URI = "git://git.yoctoproject.org/opkg-utils \
           "
