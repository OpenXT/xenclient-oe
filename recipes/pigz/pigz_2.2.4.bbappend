SRC_URI = "${DEBIAN_MIRROR}/main/p/pigz/pigz_${PV}.orig.tar.gz \
           file://ldflags.patch"
