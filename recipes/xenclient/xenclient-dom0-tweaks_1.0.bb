require recipes/xenclient/xenclient-dom0-tweaks.inc
