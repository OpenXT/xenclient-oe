PRINC = "1"
FILESEXTRAPATHS := "${THISDIR}/${PN}-${PV}"
SRC_URI += "file://minimal-settings-helper.patch"
