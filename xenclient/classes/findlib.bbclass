DEPENDS_append = " ocaml-findlib-cross ocaml-findlib-config"
export OCAMLFIND_CONF = "${OCAML_FINDLIB_CONF}"

