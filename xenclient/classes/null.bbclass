# Empty class. (Used in xenclient-src-package and xenclient-image-src-package.)
