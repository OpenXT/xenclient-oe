addtask src_info_all before do_build
