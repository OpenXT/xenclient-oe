inherit xenclient-repo

do_rm_work() {
        :
}
