PRINC = "1"

BBCLASSEXTEND = "native"
