PRINC = "1"
FILESEXTRAPATHS := "${THISDIR}"

SRC_URI += "file://linux-3.8-compile.patch;patch=1"
