DEPENDS_virtclass-native += "gnutls"
CURLGNUTLS_virtclass-native = ""
