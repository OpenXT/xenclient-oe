DEBOOTSTRAP_SUITE="wheezy"
DEBOOTSTRAP_ARCH="i386"
DEBOOTSTRAP_PKGS="git"

include recipes/debootstrap/debootstrap.inc

SRC_URI[md5sum] = "f793c7f39bdf75611bd46a25f8d253dd"
SRC_URI[sha256sum] = "0b0f04af20dfe57f5e5fb6abf4241c43daf43440e05138149363eef573a12313"
