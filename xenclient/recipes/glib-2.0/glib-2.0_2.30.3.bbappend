PRINC = "2"

EXTRA_OECONF += " --enable-static "

