require recipes/ioemu/ioemu.inc

SRCREV_source = "${OPENXT_TAG}"
SRCREV_patchqueue = "${OPENXT_TAG}"
