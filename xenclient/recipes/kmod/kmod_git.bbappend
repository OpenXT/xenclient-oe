SRC_URI = "git://git.kernel.org/pub/scm/utils/kernel/kmod/kmod.git \
           file://0001-man-disable-man-page-generation-because-we-don-t-hav.patch \
"
