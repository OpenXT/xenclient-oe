PRINC = "1"
SRC_URI = "http://archive.eclipse.org/eclipse/downloads/drops/R-3.6.2-201102101200/ecjsrc-${PV}.zip"
