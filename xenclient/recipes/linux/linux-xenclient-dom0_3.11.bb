DESCRIPTION = "Linux kernel XenClient dom0"
COMPATIBLE_MACHINE = "(xenclient-dom0)"

require linux-xenclient-${PV}.inc

