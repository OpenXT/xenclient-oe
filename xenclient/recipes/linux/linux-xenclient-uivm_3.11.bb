DESCRIPTION = "Linux kernel XenClient uivm"
COMPATIBLE_MACHINE = "(xenclient-uivm)"

require linux-xenclient-${PV}.inc
