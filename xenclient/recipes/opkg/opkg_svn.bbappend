FILESEXTRAPATHS := "${THISDIR}/${PN}"
SRC_URI += "file://lock-cloexec.patch"
