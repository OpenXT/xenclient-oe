require recipes/qemu-dm/qemu-dm.inc

SRCREV_source = "${OPENXT_TAG}"
SRCREV_patchqueue = "${OPENXT_TAG}"
