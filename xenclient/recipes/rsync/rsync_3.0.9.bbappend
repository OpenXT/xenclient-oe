PRINC = "1"
EXTRA_OECONF += "--enable-xattr-support"
