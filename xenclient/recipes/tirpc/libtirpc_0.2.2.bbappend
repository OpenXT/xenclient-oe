FILESEXTRAPATHS := "${THISDIR}/${PN}"
SRC_URI += "file://compile-static-with-fPIC.patch"
