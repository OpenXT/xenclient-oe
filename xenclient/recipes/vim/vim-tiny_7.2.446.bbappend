PRINC = "1"

DEPENDS += "libselinux"
EXTRA_OECONF += "--enable-selinux --disable-acl"
