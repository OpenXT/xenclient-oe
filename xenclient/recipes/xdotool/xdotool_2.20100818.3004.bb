require recipes/xdotool/xdotool_2.inc
SRC_URI[md5sum] = "683243c9bde9393f17428833acc12334"
SRC_URI[sha256sum] = "2920736ec7c9e06a550eadeb24b3d94f5d542f237fca8fa6e9ab3beab354e191"
