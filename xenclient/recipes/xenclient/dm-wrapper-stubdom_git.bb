require dm-wrapper.inc

SRCREV = "${OPENXT_TAG}"

EXTRA_OECONF += "--disable-syslog"
