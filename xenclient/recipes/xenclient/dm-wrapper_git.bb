require dm-wrapper.inc

SRCREV = "${OPENXT_TAG}"
