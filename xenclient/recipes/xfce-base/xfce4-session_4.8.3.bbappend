PRINC = "1"
do_configure_prepend() {
    export ac_cv_path_ICEAUTH=/usr/bin/iceauth
}
