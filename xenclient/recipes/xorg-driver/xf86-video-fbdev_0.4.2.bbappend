PRINC = "1"
FILESEXTRAPATHS := "${THISDIR}/${PN}"
SRC_URI += "file://fbdev-randr1.2.patch"
