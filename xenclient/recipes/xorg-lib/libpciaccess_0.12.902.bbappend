PRINC = "1"

FILESEXTRAPATHS := "${THISDIR}/${PN}"

SRC_URI += "file://remove_mtrr.patch"


